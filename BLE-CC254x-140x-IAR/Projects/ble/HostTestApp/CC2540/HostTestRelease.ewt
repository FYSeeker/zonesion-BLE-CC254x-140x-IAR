<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>CC2540USB</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>CC2540EM</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>CC2540EM-SBL</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>CC2540EM-EBL</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>CC2540USB-UBL</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>CC2540SPI</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>CC2540SPI-SBL</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>CC2540SPI-EBL</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <group>
    <name>APP</name>
    <file>
      <name>$PROJ_DIR$\..\Source\hci_ext_app.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\hci_ext_app.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\HostTest_Main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\OSAL_HostTest.c</name>
    </file>
  </group>
  <group>
    <name>HAL</name>
    <group>
      <name>Common</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\common\hal_drivers.c</name>
      </file>
    </group>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_adc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_assert.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_board.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_defs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_drivers.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_key.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_lcd.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_led.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_rpc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_sleep.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_timer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_uart.h</name>
      </file>
    </group>
    <group>
      <name>Target</name>
      <group>
        <name>CC2540EB</name>
        <group>
          <name>Config</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_board_cfg.h</name>
          </file>
        </group>
        <group>
          <name>Drivers</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_adc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_aes.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_dma.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_flash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_key.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_lcd.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_led.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_sleep.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_startup.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_uart.c</name>
          </file>
        </group>
        <group>
          <name>Includes</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_aes.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_ccm.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_dma.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_mcu.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_types.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>CC2540USB</name>
        <group>
          <name>Config</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_board_cfg.h</name>
          </file>
        </group>
        <group>
          <name>Drivers</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_adc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_aes.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_dma.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_flash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_key.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_lcd.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_led.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_sleep.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_startup.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_timer.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_uart.c</name>
          </file>
        </group>
        <group>
          <name>Includes</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_aes.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_dma.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_mcu.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_types.h</name>
          </file>
        </group>
        <group>
          <name>USB</name>
          <group>
            <name>class_cdc</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\class_cdc\usb_cdc.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\class_cdc\usb_cdc_descriptor.s51</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\class_cdc\usb_cdc_hooks.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\class_cdc\usb_cdc_hooks.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\class_cdc\usb_firmware_library_config.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\class_cdc\usb_firmware_library_config.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\class_cdc\usb_firmware_library_headers.h</name>
            </file>
          </group>
          <group>
            <name>library</name>
            <group>
              <name>cc2540</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\cc2540\usb_board_cfg.h</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\cc2540\usb_interrupt.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\cc2540\usb_suspend.c</name>
              </file>
            </group>
            <group>
              <name>usb</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\usb\usb_descriptor_parser.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\usb\usb_descriptor_parser.h</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\usb\usb_framework.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\usb\usb_framework_structs.h</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\usb\usb_interrupt.h</name>
              </file>
            </group>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\usb_descriptor.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\usb_framework.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\usb_reg.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\usb_standard_requests.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\usb_standard_requests.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\usb_suspend.h</name>
            </file>
          </group>
        </group>
      </group>
    </group>
  </group>
  <group>
    <name>LIB</name>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CC2540DB\bin\CC2540_BLE.lib</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\Common\bin\CC254x_BLE_HCI_TL_Full.lib</name>
    </file>
  </group>
  <group>
    <name>NPI</name>
    <file>
      <name>$PROJ_DIR$\..\..\common\npi\npi_np\npi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\npi\npi_np\NPI.h</name>
    </file>
  </group>
  <group>
    <name>OSAL</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\include\bcomdef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\osal_bufmgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\osal_cbtimer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL_ClockBLE.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL_Memory.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL_PwrMgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\mcu\cc2540\osal_snv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL_Timers.c</name>
    </file>
  </group>
  <group>
    <name>PROFILES</name>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\gap.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\gapbondmgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\gapbondmgr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Include\gapgattserver.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\host\gatt_uuid.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\include\gatt_uuid.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Include\gattservapp.h</name>
    </file>
  </group>
  <group>
    <name>TOOLS</name>
    <file>
      <name>$PROJ_DIR$\..\..\config\buildComponents.cfg</name>
    </file>
    <file>
      <name>$PROJ_DIR$\buildConfig.cfg</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\cc2540\OnBoard.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\cc2540\OnBoard.h</name>
    </file>
  </group>
</project>


